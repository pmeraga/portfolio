## NOVA_espidf/sdkconfig.defaults
```kconfig
CONFIG_FREERTOS_UNICORE=y
CONFIG_I2C_MASTER_SCL=22
CONFIG_I2C_MASTER_SDA=21
CONFIG_I2C_MASTER_FREQ_HZ=400000
CONFIG_MAIN_TASK_STACK_SIZE=4096
```
